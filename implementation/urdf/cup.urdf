Commit message: Added gripper detection to cup

File: implementation/urdf/cup.urdf (robot description, URDF)
Before this commit: robot cup, 1 links, 0 joints
Links:
- link cup_base_link: geometry visual cylinder length=0.04 radius=0.015
